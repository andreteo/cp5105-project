options:
  parameters:
    generate_options: qt_gui
    id: andreteo
    output_language: python
    title: HR/BR Using Wireless and Machine Learning
  states: {}

blocks:
- name: frequency
  id: variable_qtgui_range
  parameters:
    start: '-samp_rate/2'
    step: '1'
    stop: samp_rate/2
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: signal_source_freq
  id: variable
  parameters:
    value: ''
  states: {state: disabled}
- name: variable_qtgui_chooser_0
  id: variable_qtgui_chooser
  parameters:
    label0: 'Frequency: 1000'
    label1: 'Frequency: 2000'
    label2: 'Frequency: 5000'
    num_opts: '3'
    option0: '1000'
    option1: '2000'
    option2: '5000'
    type: int
    value: '1000'
  states: {state: disabled}
- name: FrequencyShifter_0
  id: FrequencyShifter
  parameters:
    frequency: frequency
    samp_rate: samp_rate
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/4
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/8
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: https://wiki.gnuradio.org/index.php?title=Streams_and_Vectors
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [FrequencyShifter_0, '0', blocks_throttle2_0, '0']
- [analog_noise_source_x_0, '0', low_pass_filter_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', FrequencyShifter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
