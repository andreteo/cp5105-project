options:
  parameters:
    author: atsy_
    generate_options: qt_gui
    id: audo_fmcw_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: buffer_size
  id: variable
  parameters:
    value: '32768'
  states: {}
- name: bw
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: freq
  id: variable
  parameters:
    value: '500'
  states: {}
- name: pi
  id: variable
  parameters:
    value: math.pi
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: vco_sensitivity
  id: variable
  parameters:
    value: 2*pi*bw
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '0.7'
    low_cutoff_freq: '0.1'
    samp_rate: '1000'
    type: fir_filter_fff
    width: '0.1'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '3'
    low_cutoff_freq: '0.8'
    samp_rate: '1000'
    type: fir_filter_fff
    width: '0.1'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: cw_rx_mixed.dat
    type: complex
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("ping")
    period: '2'
  states: {state: disabled}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1'
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1.0'
    samp_rate: samp_rate
    sensitivity: vco_sensitivity
  states: {}
- name: blocks_vco_c_1
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: vco_sensitivity
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    N: '3'
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import math

      class mfcw_vco_control(gr.sync_block):
          """
          Generates a stepped frequency control signal (float) to drive a VCO block
          in GNU Radio. The VCO then outputs a multi-frequency waveform in time.

          The control waveform cycles from:
            f0, f0 + delta_f, ..., f0 + (N-1)*delta_f
          staying at each step for 'dwell_samples' samples,
          and repeats indefinitely.

          All frequency units here are in Hz (converted to rad/s before output).
          """

          def __init__(self, samp_rate=1e6, f0=1e5, N=5, delta_f=1e5, dwell_samples=1000):
              gr.sync_block.__init__(
                  self,
                  name="mfcw_vco_control",
                  in_sig=None,
                  out_sig=[np.float32]
              )
              self.samp_rate = float(samp_rate)
              self.f0 = float(f0)
              self.N = int(N)
              self.delta_f = float(delta_f)
              self.dwell_samples = int(dwell_samples)

              # Build the control waveform array
              # Frequencies in rad/s = 2*pi*(f0 + i*delta_f)
              self.waveform = []
              for i in range(self.N):
                  freq_hz = self.f0 + i * self.delta_f
                  freq_rad = 2.0 * math.pi * freq_hz
                  # fill 'dwell_samples' entries with freq_rad
                  self.waveform.extend([freq_rad] * self.dwell_samples)

              # Convert to numpy float32 array
              self.waveform = np.array(self.waveform, dtype=np.float32)
              self.waveform_len = len(self.waveform)

              # Pointer for indexing the waveform
              self.ptr = 0

          def work(self, input_items, output_items):
              out = output_items[0]
              out_len = len(out)
              for i in range(out_len):
                  out[i] = self.waveform[self.ptr]
                  self.ptr = (self.ptr + 1) % self.waveform_len
              return out_len
    delta_f: 1e3
    dwell_samples: '1000'
    f0: 1e3
    samp_rate: samp_rate
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          def __init__(self, samp_rate=1e6, bw=100e3, chirp_duration=50e-6, idle_duration=500e-6):
              gr.sync_block.__init__(
                  self,
                  name="FMCW Pulse Triggered",
                  in_sig=None,
                  out_sig=[np.float32]
              )
              
              self.samp_rate = int(samp_rate)
              self.bw = bw
              self.chirp_samples = int(chirp_duration * self.samp_rate)
              self.idle_samples = int(idle_duration * self.samp_rate)
              self.total_samples = self.chirp_samples + self.idle_samples

              self.chirp = np.linspace(0.0, 1.0, self.chirp_samples, dtype=np.float32)
              self.idle = np.zeros(self.idle_samples, dtype=np.float32)
              self.pulse = np.concatenate((self.chirp, self.idle))

              self.send_pulse = False
              self.ptr = 0

              # Register message input
              self.message_port_register_in(pmt.intern("trigger"))
              self.set_msg_handler(pmt.intern("trigger"), self.trigger_pulse)

          def trigger_pulse(self, msg):
              self.send_pulse = True
              self.ptr = 0

          def work(self, input_items, output_items):
              out = output_items[0]
              n = len(out)

              if self.send_pulse:
                  remaining = self.total_samples - self.ptr
                  to_copy = min(n, remaining)
                  out[:to_copy] = self.pulse[self.ptr:self.ptr + to_copy]

                  if to_copy < n:
                      out[to_copy:] = 0.0

                  self.ptr += to_copy
                  if self.ptr >= self.total_samples:
                      self.send_pulse = False
              else:
                  out[:] = 0.0

              return len(out)
    bw: bw
    chirp_duration: '50e-05'
    idle_duration: '0.0005'
    samp_rate: int(samp_rate)
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self, name="Unwrap Phase", in_sig=[np.complex64], out_sig=[np.float32])
              self.last_angle = 0.0

          def work(self, input_items, output_items):
              phase = np.unwrap(np.angle(input_items[0]))
              output_items[0][:] = phase
              return len(output_items[0])
  states: {state: disabled}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: buffer_size
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '2400000000'
    samplerate: int(samp_rate)
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: buffer_size
    filter_source: '''Auto'''
    frequency: '2400000000'
    gain1: '''slow_attack'''
    len_tag_key: ''
    manual_gain1: '40'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e3
    decim: '1'
    gain: '1'
    samp_rate: 10e3
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '2000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_BLACKMAN
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: '1000'
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: '1000'
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_3
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    name: '"Simulated FMCW - VCO Output - Frequency Domain"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_4
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    label1: ''
    name: '"Simulated FMCW - VCO Output - Time Domain"'
    size: 1024*4
    srate: samp_rate
    type: complex
    update_time: '0.1'
    ylabel: ''
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: 1024*4
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: '1000'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: '1000'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_4
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_5
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [analog_sig_source_x_0, '0', iio_pluto_sink_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_5, '0']
- [analog_sig_source_x_1, '0', blocks_vco_c_0, '0']
- [band_pass_filter_0, '0', qtgui_freq_sink_x_2, '0']
- [band_pass_filter_0, '0', qtgui_time_sink_x_2, '0']
- [band_pass_filter_1, '0', qtgui_freq_sink_x_1, '0']
- [band_pass_filter_1, '0', qtgui_time_sink_x_3, '0']
- [blocks_message_strobe_0, strobe, epy_block_1, trigger]
- [blocks_multiply_conjugate_cc_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', low_pass_filter_1, '0']
- [blocks_multiply_conjugate_cc_0, '0', qtgui_freq_sink_x_4, '0']
- [blocks_multiply_conjugate_cc_0, '0', qtgui_time_sink_x_4, '0']
- [blocks_vco_c_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_vco_c_0, '0', blocks_throttle2_1, '0']
- [blocks_vco_c_0, '0', iio_pluto_sink_0, '0']
- [blocks_vco_c_0, '0', qtgui_freq_sink_x_3, '0']
- [blocks_vco_c_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0, '0', blocks_vco_c_0, '0']
- [epy_block_1, '0', blocks_vco_c_0, '0']
- [epy_block_2, '0', band_pass_filter_0, '0']
- [epy_block_2, '0', band_pass_filter_1, '0']
- [iio_pluto_source_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_1, '0']
- [low_pass_filter_1, '0', blocks_file_sink_0, '0']
- [low_pass_filter_1, '0', qtgui_freq_sink_x_4, '0']
- [low_pass_filter_1, '0', qtgui_time_sink_x_4, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
