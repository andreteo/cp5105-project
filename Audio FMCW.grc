options:
  parameters:
    author: Balint Seeber
    category: Custom
    comment: Adjust 'd' while running to compensate for audio HW delay
    description: 'R1 (More info: https://wiki.spench.net/wiki/RF)'
    generate_options: qt_gui
    id: audio_fmcw
    output_language: python
    title: Audio FMCW RADAR
  states: {}

blocks:
- name: doppler_bins
  id: variable
  parameters:
    value: '64'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: int(2**math.ceil(math.log(samps_per_chirp) / math.log(2)))
  states: {state: disabled}
- name: fft_size
  id: variable
  parameters:
    value: 2048 /2
  states: {state: disabled}
- name: fft_size
  id: variable
  parameters:
    value: int(samps_per_chirp)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(48000)
  states: {}
- name: samps_per_chirp
  id: variable
  parameters:
    value: samp_rate / abs(rate)
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: float
  states: {state: disabled}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: f
    type: float
  states: {state: disabled}
- name: analog_const_source_x_2
  id: analog_const_source_x
  parameters:
    const: 1-run_array
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: rate
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: run_array
    freq: phase_rate
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: any_0
  id: any
  parameters:
    block_desc: ''
    block_maker: baz.overlap(8, fft_size, fft_size/(2), samp_rate)
    num_inputs: '1'
    num_outputs: '1'
  states: {state: disabled}
- name: any_1
  id: any
  parameters:
    block_desc: ''
    block_maker: baz.swap(4, doppler_bins/2)
    num_inputs: '1'
    num_outputs: '1'
  states: {}
- name: any_2
  id: any
  parameters:
    block_desc: ''
    block_maker: baz.overlap(8, (fft_size*doppler_bins), (fft_size*doppler_bins)/(8*4))
    num_inputs: '1'
    num_outputs: '1'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: baz_delay_0
  id: baz_delay
  parameters:
    delay: d
    num_ports: '1'
    type: float
    vlen: '1'
  states: {}
- name: baz_plot_sink_0
  id: baz_plot_sink
  parameters:
    data_len: fft_size
    ref_level: '50'
    samp_rate: samp_rate
    title: Plot
    y_divs: '10'
    y_per_div: '10'
  states: {state: disabled}
- name: baz_waterfall_sink_0
  id: baz_waterfall_sink
  parameters:
    always_run: 'False'
    data_len: fft_size/2
    dynamic_range: '20'
    freqvar: None
    grid_pos: 0, 0, 1, 1
    ref_level: '10'
    ref_scale: '2.0'
    title: Waterfall Plot
    win_size: 1024*2*0 + 1440, 1024*0 + 768*0 + 640
    x_offset: '0'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: fft_size/2
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters:
    vlen: fft_size
  states: {state: disabled}
- name: blocks_complex_to_mag_0_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: fft_size/2
    n: fft_size
    offset: fft_size/2
    type: complex
  states: {}
- name: blocks_keep_m_in_n_1
  id: blocks_keep_m_in_n
  parameters:
    m: int(samps_per_chirp)
    n: fft_size
    offset: '0'
    type: complex
  states: {state: disabled}
- name: blocks_keep_m_in_n_2
  id: blocks_keep_m_in_n
  parameters:
    m: doppler_bins*(fft_size/2)
    n: doppler_bins*(fft_size)
    offset: '0'
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '1'
    type: float
    vlen: fft_size/2
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: '16'
    type: float
    vlen: fft_size
  states: {state: disabled}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 10.**(1.*mul/10.0)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10.**(1.*mul/10.0)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: numpy.exp(1j*phase)
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_3_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '255.'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_4
  id: blocks_multiply_const_vxx
  parameters:
    const: 10.**(1.*demod_mul/10.)
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fft_size/2
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size * doppler_bins
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size / 2
    type: complex
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1.0'
    samp_rate: '1.0'
    sensitivity: math.pi
  states: {}
- name: blocks_vco_c_0_0
  id: blocks_vco_c
  parameters:
    amplitude: '1.0'
    samp_rate: '1.0'
    sensitivity: math.pi
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '1.0'
    samp_rate: '1.0'
    sensitivity: math.pi
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_2
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size / 2
    type: float
  states: {state: disabled}
- name: blocks_vector_to_stream_3
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size*doppler_bins
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: fmcw.wav
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {state: disabled}
- name: colouriser
  id: any
  parameters:
    block_desc: ''
    block_maker: baz.colouriser(self.ref_level, self.dyn_range)
    num_inputs: '1'
    num_outputs: '1'
  states: {}
- name: colouriser2
  id: any
  parameters:
    block_desc: ''
    block_maker: baz.colouriser(self.ref_level, self.dyn_range)
    num_inputs: '1'
    num_outputs: '1'
  states: {state: disabled}
- name: d
  id: variable_slider
  parameters:
    converver: int_converter
    label: ''
    max: '1000'
    min: '0'
    num_steps: '1000'
    style: wx.SL_HORIZONTAL
    value: 350-100*0
  states: {}
- name: demod_mul
  id: variable_slider
  parameters:
    converver: float_converter
    label: ''
    max: '10'
    min: '-60'
    num_steps: '70'
    style: wx.SL_HORIZONTAL
    value: '-30'
  states: {}
- name: dyn_range
  id: variable_slider
  parameters:
    converver: float_converter
    label: ''
    max: '100'
    min: '0'
    num_steps: '100'
    style: wx.SL_HORIZONTAL
    value: '10'
  states: {}
- name: f
  id: variable_slider
  parameters:
    converver: float_converter
    label: ''
    max: '1'
    min: '-1'
    num_steps: '100'
    style: wx.SL_HORIZONTAL
    value: '0'
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: list(window.blackmanharris(fft_size))*0 + [1]*fft_size*1
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_size * doppler_bins
    forward: 'True'
    nthreads: '4'
    shift: 'False'
    type: complex
    window: list(window.blackmanharris(fft_size*doppler_bins))*1 + [1]*((fft_size*doppler_bins)*0)
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'False'
    shift: 'False'
    type: complex
    window: list(window.blackmanharris(fft_size))*0 + [1]*fft_size
  states: {state: disabled}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: lp_cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '500'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
    win: firdes.WIN_HAMMING
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import baz
  states: {}
- name: import_2
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_4
  id: import
  parameters:
    imports: from baz import wx_flipper
  states: {}
- name: lp_cutoff
  id: variable_slider
  parameters:
    converver: float_converter
    label: ''
    max: samp_rate/2
    min: '0'
    num_steps: '1000'
    style: wx.SL_HORIZONTAL
    value: '2500'
  states: {}
- name: mul
  id: variable_slider
  parameters:
    converver: float_converter
    label: ''
    max: '0'
    min: '-60'
    num_steps: '60'
    style: wx.SL_HORIZONTAL
    value: '-10'
  states: {}
- name: phase
  id: variable_slider
  parameters:
    converver: float_converter
    label: ''
    max: numpy.pi
    min: '-numpy.pi'
    num_steps: '1000'
    style: wx.SL_HORIZONTAL
    value: '0'
  states: {state: disabled}
- name: phase_rate
  id: variable_text_box
  parameters:
    converver: float_converter
    formatter: None
    label: ''
    value: 1./3*2 + 10*0
  states: {}
- name: rate
  id: variable_text_box
  parameters:
    converver: float_converter
    formatter: None
    label: ''
    value: 1./10*0 + -50*1 + 2*0 + -10*0
  states: {}
- name: ref_level
  id: variable_slider
  parameters:
    converver: float_converter
    label: ''
    max: '50'
    min: '-50'
    num_steps: '100'
    style: wx.SL_HORIZONTAL
    value: 0+10
  states: {}
- name: run_array
  id: variable_check_box
  parameters:
    'false': '0'
    label: ''
    'true': '1'
    value: '0'
  states: {}
- name: sdl_sink
  id: baz_sdl_sink
  parameters:
    display_height: fft_size/2
    display_width: doppler_bins
    filename: ''
    font_path: ''
    fps: '0'
    height: fft_size/2
    manual_flip: 'True'
    mode: 'True'
    num_channels: '1'
    type: byte
    width: doppler_bins
  states: {}
- name: sdl_sink2
  id: baz_sdl_sink
  parameters:
    display_height: 4 * int(abs(rate) / phase_rate)
    display_width: 2 * fft_size/2
    filename: ''
    font_path: ''
    fps: '0'
    height: int(abs(rate) / phase_rate)
    manual_flip: 'True'
    mode: 'True'
    num_channels: '1'
    type: byte
    width: fft_size/2
  states: {state: disabled}
- name: variable_any_code_0
  id: variable_any_code
  parameters:
    callback_mode: post
    code: self.colouriser.set_ref_lvl(self.ref_level)
    deps: '{''ref_lvl'': ref_level}'
    first_eval: none
    injection: plain
    value: None
  states: {}
- name: variable_any_code_1
  id: variable_any_code
  parameters:
    callback_mode: post
    code: self.colouriser.set_dyn_rng(self.dyn_range)
    deps: '{''dyn_rng'': dyn_range}'
    first_eval: none
    injection: plain
    value: None
  states: {}
- name: variable_any_code_2_0
  id: variable_any_code
  parameters:
    callback_mode: post
    code: wx_flipper.WX_Flipper(self.GetWin(), self.sdl_sink.flip, 40, force_idle=True)
    deps: '{}'
    first_eval: post
    injection: variable
    value: None
  states: {}
- name: variable_any_code_2_0_0
  id: variable_any_code
  parameters:
    callback_mode: post
    code: wx_flipper.WX_Flipper(self.GetWin(), self.sdl_sink2.flip, 40, force_idle=True)
    deps: '{}'
    first_eval: post
    injection: variable
    value: None
  states: {state: disabled}
- name: wxgui_fftsink2_0
  id: wxgui_fftsink2
  parameters:
    average: 'False'
    avg_alpha: '0'
    baseband_freq: '0'
    fft_rate: '15'
    fft_size: '1024'
    freqvar: None
    peak_hold: 'False'
    ref_level: '0'
    ref_scale: '2.0'
    samp_rate: samp_rate
    title: FFT Plot
    type: float
    win: None
    y_divs: '10'
    y_per_div: '10'
  states: {state: disabled}
- name: wxgui_fftsink2_1
  id: wxgui_fftsink2
  parameters:
    average: 'False'
    avg_alpha: '0'
    baseband_freq: '0'
    fft_rate: '15'
    fft_size: '1024'
    freqvar: None
    peak_hold: 'False'
    ref_level: '0'
    ref_scale: '2.0'
    samp_rate: samp_rate
    title: FFT Plot
    type: complex
    win: None
    y_divs: '10'
    y_per_div: '10'
  states: {state: disabled}
- name: wxgui_fftsink2_2
  id: wxgui_fftsink2
  parameters:
    average: 'False'
    avg_alpha: '0'
    baseband_freq: '0'
    fft_rate: '15'
    fft_size: '1024'
    freqvar: None
    peak_hold: 'False'
    ref_level: '0'
    ref_scale: '2.0'
    samp_rate: samp_rate
    title: FFT Plot
    type: float
    win: None
    y_divs: '10'
    y_per_div: '10'
  states: {state: disabled}
- name: wxgui_scopesink2_0
  id: wxgui_scopesink2
  parameters:
    ac_couple: 'False'
    num_inputs: '1'
    samp_rate: samp_rate
    t_scale: '0'
    title: Scope Plot
    trig_mode: wxgui.TRIG_MODE_AUTO
    type: float
    v_offset: '0'
    v_scale: '1'
    xy_mode: 'False'
    y_axis_label: Counts
  states: {state: disabled}
- name: wxgui_scopesink2_1
  id: wxgui_scopesink2
  parameters:
    ac_couple: 'False'
    num_inputs: '1'
    samp_rate: samp_rate
    t_scale: '0'
    title: Scope Plot
    trig_mode: wxgui.TRIG_MODE_AUTO
    type: float
    v_offset: '0'
    v_scale: '0'
    xy_mode: 'False'
    y_axis_label: Counts
  states: {state: disabled}
- name: wxgui_waterfallsink2_0
  id: wxgui_waterfallsink2
  parameters:
    average: 'False'
    avg_alpha: '0'
    baseband_freq: '0'
    dynamic_range: '100'
    fft_rate: '15'
    fft_size: '512'
    freqvar: None
    ref_level: '0'
    ref_scale: '2.0'
    samp_rate: samp_rate
    title: Waterfall Plot
    type: float
    win: None
  states: {state: disabled}
- name: wxgui_waterfallsink2_1
  id: wxgui_waterfallsink2
  parameters:
    average: 'False'
    avg_alpha: '0'
    baseband_freq: '0'
    dynamic_range: '100'
    fft_rate: '30'
    fft_size: 512*4
    freqvar: None
    ref_level: '0'
    ref_scale: '2.0'
    samp_rate: samp_rate
    title: Waterfall Plot
    type: complex
    win: None
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', blocks_multiply_const_vxx_3_0, '0']
- [analog_const_source_x_0, '0', blocks_vco_f_0, '0']
- [analog_const_source_x_2, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', baz_delay_0, '0']
- [analog_sig_source_x_0, '0', blocks_vco_c_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_vco_f_0, '0']
- [analog_sig_source_x_0, '0', wxgui_scopesink2_0, '0']
- [analog_sig_source_x_0_1, '0', blocks_add_xx_0, '0']
- [any_0, '0', blocks_stream_to_vector_0, '0']
- [any_0, '0', wxgui_waterfallsink2_1, '0']
- [any_1, '0', colouriser, '0']
- [any_2, '0', blocks_stream_to_vector_0_0, '0']
- [audio_source_0, '0', hilbert_fc_0, '0']
- [audio_source_0, '0', wxgui_waterfallsink2_0, '0']
- [baz_delay_0, '0', blocks_vco_c_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_xx_1, '1']
- [blocks_complex_to_float_0, '0', high_pass_filter_0, '0']
- [blocks_complex_to_float_0, '0', wxgui_fftsink2_2, '0']
- [blocks_complex_to_float_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_complex_to_float_0_0_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_complex_to_mag_0_0, '0', blocks_keep_one_in_n_0_0, '0']
- [blocks_complex_to_mag_0_1, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_keep_m_in_n_1, '0', blocks_complex_to_float_0, '0']
- [blocks_keep_m_in_n_2, '0', blocks_complex_to_mag_0_1, '0']
- [blocks_keep_one_in_n_0, '0', baz_waterfall_sink_0, '0']
- [blocks_keep_one_in_n_0_0, '0', baz_plot_sink_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', any_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', any_2, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', audio_sink_0_0, '1']
- [blocks_multiply_const_vxx_2, '0', blocks_complex_to_float_0_0_0, '0']
- [blocks_multiply_const_vxx_4, '0', blocks_wavfile_sink_0, '0']
- [blocks_multiply_const_vxx_4, '0', wxgui_scopesink2_1, '0']
- [blocks_multiply_xx_1, '0', blocks_complex_to_float_0_0_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_vector_to_stream_2, '0']
- [blocks_nlog10_ff_0_0, '0', any_1, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_1, '0', blocks_complex_to_mag_0, '0']
- [blocks_vco_c_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_vco_c_0_0, '0', blocks_complex_to_float_0_0, '0']
- [blocks_vco_c_0_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_vco_c_0_0, '0', blocks_multiply_xx_1, '0']
- [blocks_vco_f_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_vco_f_0, '0', wxgui_fftsink2_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_keep_m_in_n_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_keep_m_in_n_1, '0']
- [blocks_vector_to_stream_2, '0', colouriser2, '0']
- [blocks_vector_to_stream_3, '0', blocks_keep_m_in_n_2, '0']
- [colouriser, '0', blocks_null_sink_0, '0']
- [colouriser, '0', sdl_sink, '0']
- [colouriser2, '0', sdl_sink2, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_0_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [fft_vxx_0, '0', fft_vxx_1, '0']
- [fft_vxx_0_0, '0', blocks_vector_to_stream_3, '0']
- [fft_vxx_1, '0', blocks_vector_to_stream_1, '0']
- [high_pass_filter_0, '0', blocks_multiply_const_vxx_4, '0']
- [hilbert_fc_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [hilbert_fc_0, '0', wxgui_fftsink2_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
